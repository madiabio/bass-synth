# Keil uVision project embedded-assignment.uvprojx, settings and files
target Target 1 (6230000::V6.23::ARMCLANG)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ./: config.h main.c ES_Lib.h ES_Library.lib function_gen.h function_gen.c notes.h notes.c waveforms.h waveforms.c input.h input.c i2c.c i2c.h adc.c adc.h SSI.c SSI.h LCD_Display.h LCD_Display.lib
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
